# Keil uVision project LPC11U24SPI.uvproj, settings and files
target lpclcdspi (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Cappuccino
  c flags: Optim=1
  c define: ARMCMX LPCLCD
  c include: ..\LPCLibrary\CMSISv2p00_LPC11Uxx\inc;..\armcmx\lpc11uxx;..\armcmx;..\armcmx\tools\SerialRAM;..\armcmx\tools\Ethernet
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group startup
    ./: startup_LPC11Uxx.s
  group main
    ./: main.cpp
  group CMSIS
    ../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: core_cm0.c system_LPC11Uxx.c
  group armcmx
    ../armcmx/lpc11uxx/: delay_systick.c gpio.c usart.c i2c.c spi_core.c
    ../armcmx/: armcmx.h Print.cpp I2CBus.cpp Stream.cpp USARTSerial.cpp SPI.cpp
    ../armcmx/tools/SerialRAM/: SPISRAM.cpp
