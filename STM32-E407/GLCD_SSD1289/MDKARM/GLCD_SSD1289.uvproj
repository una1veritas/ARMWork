# Keil uVision project GLCD_SSD1289.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: GLCD_SSD1289
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, F4DISCOVERY, HSE_VALUE=8000000
  c include: ..\..\GLCD_SSD1289;..\TouchScreen;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: main.c SSD1289.c stm32f4xx_it.c Julija.c delay.c AsciiLib.c
    ../TouchScreen/: touch_7846.c
    ../../STM32Libraries/cmcore/Boards/: system_stm32f4xx.c
  group StdPeriph
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
