# Keil uVision project LPC11U24LCD.uvproj, settings and files
target lpclcd (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11U37LCD +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin "#L" -o "$Pfirmware.bin"
  AfterMake: C:\nxp\LPCXpresso_5.2.4\lpcxpresso\bin\checksum -p LPC11U37_401 -d "$Pfirmware.bin"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: ARMCMX DELAY_SYSTICK
  c include: ..\..\LPCLibrary\CMSISv2p00_LPC11Uxx;..\..\armcmx\lpc11uxx;..\..\armcmx;..\inc;..\src;..\..\armcmx\tools\LCD;..\..\armcmx\tools\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group startup
    ./: startup_LPC11Uxx.s
  group main
    ../src/: main.cpp
  group cmsis2.0
    ../src/: system_LPC11Uxx.c
    ../../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: core_cm0.c
  group armcmx
    ../../armcmx/lpc11uxx/: gpio.c i2c.c nmi.c usart.c delay_systick.c
    ../../armcmx/: USARTSerial.cpp Stream.cpp Print.cpp I2CBus.cpp
  group LCD
    ../../armcmx/tools/LCD/: ST7032i.cpp
  group RTC
    ../../armcmx/tools/RTC/: RTC.cpp RTC.h
