# Keil uVision project GLCD_KS0108.uvproj, settings and files
target KS0108 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: GLCD_KS0108
  c flags: Optim=2 OneElfS=1
  c define: ARMCMX STM32F4_DISCOVERY USE_STDPERIPH_DRIVER HSE_VALUE=8000000
  c include: ..\..\GLCD_KS0108v2;..\..\STM32Libraries\armcmx;..\..\STM32Libraries\armcmx\utility;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: startup_stm32f4xx.s
    ../: main.cpp ks0108.cpp ks0108.h Arial14.h ArduinoIcon.h SystemFont5x7.h
    ../../STM32Libraries/armcmx/utility/: stm32f4_discovery.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group stdperiph
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group armcmx
    ../../STM32Libraries/armcmx/: armcmx.c delay.c gpio.c usart.c
