# Keil uVision project HW_Calendar.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: HW_Calendar +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\HW_Calendar;..\..\..\..\..\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\..\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\Utilities\STM32_EVAL\Common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group targetmain
    ./: startup_stm32f4xx.s
    ../: main.c main.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c stm32f4xx_conf.h
    ../../../../../STM32F4xx_DSP_StdPeriph_Lib_V1.0.1/Libraries/Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval.h
    ../../../../../STM32F4xx_DSP_StdPeriph_Lib_V1.0.1/Libraries/Utilities/STM32_EVAL/Common/: stm32_eval_legacy.h
  group stdperiph
    ../../../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_dma.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_i2c.c
