# Keil uVision project i2c-rtc.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: i2c-rtc
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\stm32f4-i2c_rtc;..\..\stm32library\armcore;..\..\stm32library\CMSIS\Include;..\..\stm32library\CMSIS\STM32F4xx;..\..\stm32library\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: i2c1_drv.c i2c1_drv.h main.c st7032i.c st7032i.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
