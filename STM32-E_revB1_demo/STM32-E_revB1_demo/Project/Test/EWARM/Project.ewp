# IAR project Project.ewp, settings and files
configuration IAR_STM32F457_SK (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; STM32_E407
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_ETH_Driver\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\board\; ..\..\..\modules\; ..\Ethernet\app\; ..\Ethernet\uip\; ..\Ethernet\uip\httpd\; ..\USB\app\; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../../../board/: iar_stm32f217ze_sk.c
  group CMSIS
    ../: system_stm32f2xx.c
  group Ethernet
    ../Ethernet/app/: clock-arch.c ethernet.c uip-conf.h uipopt.h
  group Ethernet/STM32_ETH_Driver
    ../../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group Ethernet/uip
    ../Ethernet/uip/: psock.c timer.c uip.c uip_arp.c
  group Ethernet/uip/httpd
    ../Ethernet/uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group modules
    ../../../modules/: i2c1_drv.c sd_card_mode.c Sin_Table.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group USB Device/Class/HID
    ../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group USB Device/Library
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ../: main.c stm32f2xx_it.c
    ../USB/app/: usbd_desc.c
