# Keil uVision project USBHid.uvproj, settings and files
target USBHID_Release (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: USBHid +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc;..\USBDriver
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source
    ./: hiduser.c usbdesc.c usbuser.c demo.c io_event.c
    ../USBDriver/: usbhw.c usbcore.c
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group Common
    ../Common/src/: timer16.c
  group Documentation
    ./: Abstract.txt
