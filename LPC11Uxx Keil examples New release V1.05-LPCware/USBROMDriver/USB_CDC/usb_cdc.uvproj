# Keil uVision project usb_cdc.uvproj, settings and files
target LPC11Uxx FLASH (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: usb_cdc
  c flags: Optim=1 wLevel=2
  c include: ..\..\Common\inc;..\comps\hw_usbd_ip3511;..\comps\mw_common;..\comps\mw_usbd;.\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Librarry
    ../../Common/src/: system_LPC11Uxx.c startup_LPC11Uxx.s core_cm0.c clkconfig.c
  group Source
    ./src/: main.c cdc_desc.c
  group Documentation
    ./: readme.txt
