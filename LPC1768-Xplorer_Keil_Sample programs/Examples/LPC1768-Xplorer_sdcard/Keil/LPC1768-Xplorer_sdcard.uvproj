# Keil uVision project LPC1768-Xplorer_sdcard.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBHID
  c flags: Optim=3
  c include: ..\..\CMSISv1p30_LPC17xx\inc;..\..\CMSISv1p30_LPC17xx\Core\Device\NXP\LPC17xx\Include;..\..\LPC1768-Xplorer_all_peripheral_test\Common\inc
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ../../../Core/Device/NXP/LPC17xx/Source/Templates/ARM/: startup_LPC17xx.s
  group System Code
    ../../../Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC17xx.c
  group Drivers
    ../../../Drivers/src/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_uart.c sd.c ssp.c lpc1768_sd.c lpc1768_spi.c lpc17xx_gpio.c
  group Documentation
    ../: Abstract.txt
  group Main
    ../: sdcard_main.c
  group usb_vcom
    ../../../USB_VCOM/src/: cdcuser.c serial.c usbcore.c usbdesc.c usbhw.c usbuser.c vcomdemo.c
  group Common
    ../../../Common/src/: delay.c
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LPC1768S_SDcard +hex
  AfterMake: fromelf --bin ".\Obj\LPC1768S_SDcard.axf" --output ".\Obj\LPC1768S_SDcard.bin"
  c flags: Optim=1
  c include: ..\..\..\Common\inc;..\..\..\Core\Device\NXP\LPC17xx\Include;..\..\..\Drivers\inc
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
