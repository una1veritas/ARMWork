# Keil uVision project LPC1768-Xplorer_ethernet.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1768-Xplorer_ethernet +hex
  c flags: Optim=3
  c include: ..\..\CMSISv1p30_LPC17xx\Core\Device\NXP\LPC17xx\Include;..\..\CMSISv1p30_LPC17xx\inc;..\..\LPC1768-Xplorer_all_peripheral_test\Common\inc
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ../../../Core/Device/NXP/LPC17xx/Source/Templates/ARM/: startup_LPC17xx.s
  group System Code
    ../: system_LPC17xx.c
  group Main
    ../src/: ethmac.c ew_systick.c tcpip.c
    ../: easyweb.c
  group Readme
    ../: Abstract.txt
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LPC1768-Xplorer_ethenet +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c include: ..\..\..\USB_VCOM\inc;..\..\..\Common\inc;..\..\..\Drivers\inc;..\..\..\Core\Device\NXP\LPC17xx\Include;..\inc
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
