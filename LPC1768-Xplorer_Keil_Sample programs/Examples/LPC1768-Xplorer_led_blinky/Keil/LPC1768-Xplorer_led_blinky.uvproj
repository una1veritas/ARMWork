# Keil uVision project LPC1768-Xplorer_led_blinky.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1768-Xplorer_led_blinky +hex
  c flags: Optim=3
  c include: ..\..\..\Core\Device\NXP\LPC17xx\Include;..\..\..\Drivers\inc;..\..\..\Common\inc
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ../../../Core/Device/NXP/LPC17xx/Source/Templates/ARM/: startup_LPC17xx.s
  group System Code
    ../../../Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC17xx.c
  group Main
    ../: blinky.c
    ../../../Common/src/: delay.c
  group Readme
    ../: Abstract.txt
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LPC1768-Xplorer_led_blinky +hex
  AfterMake: fromelf --bin ".\OBJ\LPC1768-Xplorer_led_blinky.axf" --output ".\OBJ\LPC1768-Xplorer_led_blinky.bin"
  c flags: Optim=1
  c include: ..\..\..\Drivers\inc;..\..\..\Core\Device\NXP\LPC17xx\Include;..\..\..\Common\inc
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
