# Keil uVision project HTTP_Server.uvprojx, settings and files
target STM32F107 Flash (ARM-ADS)
  device: STM32F107RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: HTTP_Server.c HTTP_Server_CGI.c
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif llblue.jpg logo.gif pabb.gif
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/Boards/Keil/MCBSTM32C/Common/: ADC.c GLCD_SPI_STM32F10x.c Keyboard.c LED.c
  group ::CMSIS
    C:/Keil5/ARM/PACK/ARM/CMSIS/3.20.3/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: GPIO_STM32F10x.c
    RTE/Device/STM32F107RB/: RTE_Device.h startup_stm32f10x_cl.s system_stm32f10x.c
  group ::Drivers
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/Network/Driver/: PHY_DP83848C.c
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: EMAC_STM32F10x.c
  group ::Network
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/Network/Lib/ARM/: Net_CM3_L.lib
    RTE/Network/: Net_Config.c Net_Config_ETH_0.h Net_Config_HTTP_Server.h Net_Config_TCP.h Net_Config_UDP.h
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.72.0, Board Support:MCBSTM32C:A/D Converter 1.0.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, Board Support:MCBSTM32C:Keyboard 1.0.0, Board Support:MCBSTM32C:LED 1.0.0, Network:CORE 5.0.4, Network:Interface:ETH 5.0.4, Network:Service:Web Server Compact 5.0.4, Network:Socket:TCP 5.0.4, Network:Socket:UDP 5.0.4, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:Ethernet MAC 1.02.0, Drivers:Ethernet PHY:DP83848C 1.01.0
