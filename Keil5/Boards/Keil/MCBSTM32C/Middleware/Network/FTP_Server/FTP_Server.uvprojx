# Keil uVision project FTP_Server.uvprojx, settings and files
target STM32F107 Flash (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: FTP_Server
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: FTP_Server.c
  group Documentation
    ./: Abstract.txt
  group Device
    RTE/Device/STM32F107VC/: RTE_Device.h startup_stm32f10x_cl.s system_stm32f10x.c
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
  group Drivers
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/Network/Driver/: PHY_DP83848C.c
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: EMAC_STM32F10x.c MCI_STM32F10x.c SPI_STM32F10x.c
  group Board Support
    C:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/Boards/Keil/MCBSTM32C/Common/: GLCD_SPI_STM32F10x.c LED.c
  group CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil5/ARM/PACK/ARM/CMSIS/3.20.2/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group File System
    RTE/File_System/: FS_Config.c FS_Config_MC_0.h
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/FileSystem/Lib/ARM/: FS_LFN_CM3_L.lib
  group Network
    RTE/Network/: Net_Config.c Net_Config_FTP_Server.h Net_Config_TCP.h Net_Config_UDP.h Net_Config_ETH_0.h
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/Network/Interface/: FTP_Server_FS.c
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.2/Network/Lib/ARM/: Net_CM3_L.lib
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.72.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, Board Support:MCBSTM32C:LED 1.0.0, File System:CORE 5.0.4, File System:Drive:Memory Card 5.0.4, Network:CORE 5.0.4, Network:Interface:ETH 5.0.4, Network:Service:FTP Server 5.0.4, Network:Socket:TCP 5.0.4, Network:Socket:UDP 5.0.4, Device:DMA 1.0.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:Ethernet MAC 1.02.0, Drivers:Ethernet PHY:DP83848C 1.01.0, Drivers:MCI 1.01.0, Drivers:SPI 1.02.0
