# Keil uVision project Demo.uvprojx, settings and files
target STM32F107 Flash (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Demo
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Demo.c Arrows_16bpp_red.c Bulb_16bpp.c Button_16bpp.c
  group Documentation
    ./: Abstract.txt
  group Board Support
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/Boards/Keil/MCBSTM32C/Common/: ADC.c GLCD_SPI_STM32F10x.c Joystick.c Keyboard.c LED.c Touch_STMPE811.c
  group CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil/ARM/PACK/ARM/CMSIS/3.20.3/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group Device
    RTE/Device/STM32F107VC/: RTE_Device.h startup_stm32f10x_cl.s system_stm32f10x.c
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
  group Drivers
    C:/Keil/ARM/PACK/Keil/STM32F1xx_DFP/1.0.2/RTE_Driver/: I2C_STM32F10x.c
target STM32F107 MDK-Lite (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: Demo
  c flags: Optim=1
  c define: _EVAL_VERSION_
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.72.0, Board Support:MCBSTM32C:A/D Converter 1.0.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, Board Support:MCBSTM32C:Joystick 1.0.0, Board Support:MCBSTM32C:Keyboard 1.0.0, Board Support:MCBSTM32C:LED 1.0.0, Board Support:MCBSTM32C:Touchscreen 1.0.0, Device:DMA 1.0.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:I2C 1.0.0
