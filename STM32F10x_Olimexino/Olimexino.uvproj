# Keil uVision project Olimexino.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Olimexino
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD ARMCMX
  c include: ..\STM32F10x_Olimexino;..\armcmx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group User
    ./: main.c
