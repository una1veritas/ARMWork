# Keil uVision project HY32D_Paint.uvproj, settings and files
target HY32D_Paint (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: HY32D_Paint
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER F4DISCOVERY HSE_VALUE=8000000  STDSERIAL=6
  c include: ..\;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Libraries\cmcore;..\GLCD;..\TouchScreenController
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main Source Group
    ./: startup_stm32f4xx.s
    ../: stm32f4xx_it.c stm32f4xx_conf.h stm32f4xx_it.h main.cpp stdiodef.h stdiodef.c
    ../../STM32Libraries/cmcore/Boards/: system_stm32f4xx.c stm32f4_discovery.h
    ../GLCD/: SSD1289.h SSD1289.cpp
    ../TouchScreenController/: ads7846.h ads7864.cpp
  group stdperiph_driver
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_fsmc.h
  group cmcore
    ../../STM32Libraries/cmcore/: cmcore.c cmcore.h delay.c delay.h binary.h gpio.c gpio.h spi.c spi.h usart.c usart.h
    ../../STM32Libraries/cmcore/Boards/: stm32f4_discovery.h
