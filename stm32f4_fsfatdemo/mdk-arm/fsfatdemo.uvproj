# Keil uVision project fsfatdemo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: fsfatdemo +hex
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F4XX USE_STM32F4_DISCOVERY USE_USB_OTG_FS HSEVALUE=8000000
  c include: ..\..\stm32library\CMSIS\Include;..\..\stm32library\CMSIS\STM32F4xx;..\..\stm32library\STM32F4xx_StdPeriph_Driver\inc;..\..\stm32f4_fsfatdemo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group maingroup
    ./: startup_stm32f4xx.s
    ../: main.c diskio.c ff.c stm32f4_discovery.c stm32f4_discovery_sdio_sd.c system_stm32f4xx.c stm32f4_discovery_sdio_sd.h
  group stm32f4_stdperiph_driver
    ../../stm32library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
