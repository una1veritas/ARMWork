# Keil uVision project keil.uvproj, settings and files
target stdperiph test (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: keil
  c flags: Optim=1
  c include: .\mainsrc;..\stm32library\STM32F4xx_StdPeriph_Driver\inc;..\stm32library\CMSIS\Include;..\stm32library\CMSIS\STM32F4xx;.\armcore
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group mainsrc
    ./mainsrc/: main.cpp startup_stm32f4xx.s stm32f4xx_it.c system_stm32f4xx.c
  group armcore
    ./armcore/: armcore.h CharacterLCD.h delay.c delay.h gpio.c gpio.h i2c.c i2c.h Print.cpp Print.h spi.c spi.h ST7032i.cpp ST7032i.h systick.c systick.h usart.c usart.h USARTSerial.cpp USARTSerial.h binary.h
