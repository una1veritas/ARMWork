# Keil uVision project SDIO-Fatfs.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SDIO-Fatfs
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, OLIMEX_E407,  HSE_VALUE=12000000
  c include: ..\..\stm32f4-SDIO_SDFAT;..\..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32Libraries\cmcore
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: main.c stm32fxxx_it.c diskio.c ff.c system_stm32f4xx.c diskio.h sdio.c stm32f4xx_conf.h sdio.h sdio_sd.c sdio_sd.h
  group stdperiph_driver
    ../../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_spi.c
  group cmcore
    ../../../STM32Libraries/cmcore/: cmcore.c usart.c spi.c delay.c gpio.c rtc.c
