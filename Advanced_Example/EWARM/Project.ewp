# IAR project Project.ewp, settings and files
configuration STM3210C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F10x; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM3210C_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32100E_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD_VL; USE_STM32100E_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F10x; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM32100E_EVAL
configuration STM322xG_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F2xx; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM322xG_EVAL
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  group Doc
    ../: readme.txt
  group STM32_CPAL_Driver
    ../../../../../Libraries/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
  group STM32_EVAL
    ../../../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../../../Utilities/STM32_EVAL_CPAL/Common/: stm32_eval_i2c_ee_cpal.c stm32_eval_i2c_tsensor_cpal.c
  group STM32F10x/CMSIS
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s
    ../: system_stm32f10x.c
  group STM32F10x/CPAL_HAL
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
  group STM32F10x/StdPeriph_Driver
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32F10x/STM32100E-EVAL
    ../../../../../Utilities/STM32_EVAL_CPAL/STM32100E_EVAL/: stm32100e_eval_ioe_cpal.c
    ../../../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval_lcd.c
  group STM32F10x/STM3210C-EVAL
    ../../../../../Utilities/STM32_EVAL_CPAL/STM3210C_EVAL/: stm3210c_eval_ioe_cpal.c
    ../../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c
  group STM32F2xx/CMSIS
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../: system_stm32f2xx.c
  group STM32F2xx/CPAL_HAL
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f2xx/: cpal_i2c_hal_stm32f2xx.c
  group STM32F2xx/StdPeriph_Driver
    ../../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group STM32F2xx/STM322xG_EVAL
    ../../../../../Utilities/STM32_EVAL_CPAL/STM322xG_EVAL/: stm322xg_eval_ioe_cpal.c
    ../../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c
  group User
    ../: cpal_usercallback.c demo.c main.c stm32_it.c
