# Keil uVision project lpc11uxx_sd.uvproj, settings and files
target cappucino test (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: cappucino
  c flags: Optim=1
  c define: ARMCMX
  c include: ..\..\LPCLibrary\armcmx\lpc11uxx;..\..\LPCLibrary\armcmx;.\;..\inc;..\..\..\LPCLibrary\CMSISv2p00_LPC11Uxx\inc;..\..\STM32Libraries\armcmxtools\LCD;..\..\STM32Libraries\armcmxtools\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group startup
    ./: startup_LPC11Uxx.s
  group src
    ../src/: ff.c mmc_spi.c main.cpp
  group CMSIS2.0
    ../../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: system_LPC11Uxx.c core_cm0.c
  group armcmx
    ../../LPCLibrary/armcmx/lpc11uxx/: gpio.c delay_systick.c PWM0tone.c spi.c ssp.c i2c.c usart.c
    ../../STM32Libraries/armcmxtools/LCD/: ST7032i.cpp
    ../../LPCLibrary/armcmx/: Print.cpp I2CBus.cpp Stream.cpp USARTSerial.cpp
    ../../STM32Libraries/armcmxtools/RTC/: DS1307.h DS1307.cpp
