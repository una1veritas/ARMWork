# Keil uVision project CharacterLCD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CharacterLCD
  c flags: Optim=1 OneElfS=1
  c define: ARMCMX USE_STDPERIPH_DRIVER USE_VALUE=8000000 STM32F4_DISCOVERY STDSERIAL=6
  c include: ..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Libraries\armcmx;..\..\STM32Libraries\armcmx\utility;..\..\CharacterLCD;..\..\STM32Libraries\armcmxlib\ChLCD\LiquidCrystal;..\..\STM32Libraries\armcmxlib\ChLCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main Group
    ./: startup_stm32f4xx.s
    ../../STM32Libraries/armcmx/utility/: stm32f4xx_it.c system_stm32f4xx.c
    ../: main.cpp
  group armcmx
    ../../STM32Libraries/armcmx/: armcmx.c delay.c gpio.c usart.c Print.cpp gpio.h
  group stdperiph
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group armcmxlib
    ../../STM32Libraries/armcmxlib/ChLCD/LiquidCrystal/: LiquidCrystal.cpp LiquidCrystal.h
    ../../STM32Libraries/armcmxlib/ChLCD/: HD44780.h
