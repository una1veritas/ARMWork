# Keil uVision project stm32f4xx_GPIO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4xx_GPIO
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F4_DISCOVERY
  c include: ..\..\..\STM32Libraries\armcmx;..\..\..\STM32Libraries\armcmx\utility;..\..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: main.cpp
    ../../../STM32Libraries/armcmx/utility/: stm32f4_discovery.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group stdperiph
    ../../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_pwr.c
  group armcmx
    ../../../STM32Libraries/armcmx/: delay.c gpio.c armcmx.c rtc.c spi.c usart.c
