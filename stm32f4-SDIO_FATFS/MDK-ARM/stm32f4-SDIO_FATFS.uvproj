# Keil uVision project stm32f4-SDIO_FATFS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4-SDIO_FATFS
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\stm32f4-SDIO_FATFS;..\SDIO_FATFS;..\..\STM32Libraries\CMSIS\Include;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Libraries\armcore
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group maingroup
    ./: startup_stm32f4xx.s
    ../: main.c stm32fxxx_it.c system_stm32f4xx.c stm32f4_discovery.c
  group SDIOfatfs
    ../SDIO_FATFS/: diskio.c ff.c stm32f4_discovery_sdio_sd.c
  group stdperiph driver
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group armcore
    ../../STM32Libraries/armcore/: delay.c gpio.c spi.c usart.c usart.h
