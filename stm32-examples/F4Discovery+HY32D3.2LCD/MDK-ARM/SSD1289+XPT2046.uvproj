# Keil uVision project SSD1289+XPT2046.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SSD1289+XPT2046
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, OLIMEX_E407
  c include: ..\..\F4Discovery+HY32D3.2LCD;..\TouchScreen;..\..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: delay.c AsciiLib.c main.c SSD1289.c stm32f4xx_it.c Julija.h Julija.c SSD1289.h
    ../TouchScreen/: touch_7846.c
    ../../../STM32Libraries/cmcore/Boards/: system_stm32f4xx.c
  group stdperiph
    ../../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_exti.c
