# Keil uVision project SPI_FLASH_Test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SPI_FLASH_Test
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\STM32Libraries\CMSIS\Include;..\..\STM32Libraries\CMSIS\STM32F4xx;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../../STM32F4xx_StdPeriph_Examples/SPI/SPI_FLASH/: main.c readme.txt spi_flash.c spi_flash.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.c
