# Keil uVision project stm32f4-stdperiph.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4-stdperiph +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\stm32libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\stm32librarIes\CMSIS\Include;..\..\stm32libraries\CMSIS\STM32F4xx;..\..\stm32f4-stdperiph;..\..\STM32Libraries\cmcore;..\..\STM32Libraries\cmperiph;..\..\..\STM32Libraries\cmcore\utility
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group usermain
    ./: startup_stm32f4xx.s
    ../: main.cpp stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_it.h
  group stdperiph_driver
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c
  group cmcore
    ../../STM32Libraries/cmcore/: delay.c gpio.c spi.c usart.c Print.cpp SPIBus.cpp Stream.cpp USARTSerial.cpp
    ../../../STM32Libraries/cmcore/: i2c.c I2CWire.cpp
  group cmperiphlib
    ../../STM32Libraries/cmperiph/RTC/: DS1307.cpp
    ../../STM32Libraries/cmperiph/ChLCD/: ST7032i.cpp
    ../../STM32Libraries/cmperiph/Boards/: stm32f4_discovery.h
