# Keil uVision project stm32f4-usart.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4-usart
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\stm32library\STM32F4xx_StdPeriph_Driver\inc;..\..\stm32f4-usart;..\..\stm32library\armcore;..\..\stm32library\CMSIS\Include;..\..\stm32library\CMSIS\STM32F4xx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: i2c.c main.c i2c.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c stm32f4xx_conf.h
  group armcore
    ../../stm32library/armcore/: usart.h usart.c armcore.h binary.h delay.c delay.h gpio.h gpio.c
  group cmsis stdperiph
    ../../stm32library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_pwr.c
