# Keil uVision project glcd3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: GPIO_LCD
  c flags: Optim=4 OneElfS=1
  c define: ARMCMX USE_STDPERIPH_DRIVER STM32F4_DISCOVERY HSE_VALUE=8000000 STDSERIAL=6
  c include: ..\..\GPIO_LCD;..\..\STM32Libraries\armcmx;..\..\STM32Libraries\armcmx\utility;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Libraries\armcmxlib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main src
    ../../STM32Libraries/armcmx/utility/: stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c
    ./: startup_stm32f4xx.s
    ../: main_example.cpp ks0108example.cpp
  group stdperiph
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group armcmx
    ../../STM32Libraries/armcmx/: armcmx.c armcmx.h delay.c delay.h gpio.c gpio.h usart.c usart.h Print.cpp Stream.cpp Print.h
  group GLCD
    ../../STM32Libraries/armcmxlib/GLCD/KS0108/: glcd.cpp glcd_Device.cpp gText.cpp glcd.h
    ../../STM32Libraries/armcmxlib/GLCD/KS0108/include/: glcd_Device.h gText.h
