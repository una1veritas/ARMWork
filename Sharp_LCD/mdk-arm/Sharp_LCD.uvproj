# Keil uVision project Sharp_LCD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Sharp_LCD
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER F4DISCOVERY HSE_VALUE=8000000 STDSERIAL=6
  c include: ..\..\Sharp_LCD;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Libraries\cmcore;..\..\STM32Libraries\cmcore\utility
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../../STM32Libraries/cmcore/utility/: stdiodef.c stm32f4xx_it.c stm32f4xx_conf.h stm32f4_discovery.h system_stm32f4xx.c stdiodef.h
    ../: main.cpp
  group cmcore
    ../../STM32Libraries/cmcore/: cmcore.c delay.c gpio.c usart.c spi.c spi.h
  group stdperiph_driver
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c
