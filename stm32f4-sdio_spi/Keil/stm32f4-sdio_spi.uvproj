# Keil uVision project stm32f4-sdio_spi.uvproj, settings and files
target SDIO-FATFS_SPI_Test1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4-sdio_spi +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\..\stm32f4-sdio_spi;..\..\stm32library\armcore;..\..\stm32library\armperiphlib;..\..\stm32library\CMSIS\Include;..\..\stm32library\CMSIS\STM32F4xx;..\..\stm32library\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main group
    ./: startup_stm32f4xx.s
    ../: stm32f4xx_it.c main.cpp stm32f4xx_it.h
    ../../stm32library/CMSIS/STM32F4xx/: system_stm32f4xx.c
  group armcore
    ../../stm32library/armcore/: gpio.c delay.c armcore.h i2c.c I2CWire.cpp Print.cpp spi.c SPIBus.cpp Stream.cpp usart.c USARTSerial.cpp delay.h binary.h
  group stdperiph_driver
    ../../stm32library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group armperiphlib
    ../../stm32library/armperiphlib/ChLCD/: CharacterLCD.h ST7032i.cpp ST7032i.h
    ../../stm32library/armperiphlib/RTC/: DS1307.cpp DS1307.h
