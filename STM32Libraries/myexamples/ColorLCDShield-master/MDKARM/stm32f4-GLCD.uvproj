# Keil uVision project stm32f4-GLCD.uvproj, settings and files
target SPI Test (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4-SPI
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\ColorLCDShield-master;..\..\..\CMSIS\Include;..\..\..\CMSIS\STM32F4xx;..\..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\cmcore;..\..\..\cmperiphlib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group Main
    ./: startup_stm32f4xx.s
    ../: main.cpp stm32f4xx_it.c stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.c ColorLCDShield.cpp ColorLCDShield.h stm32f4_discovery.c stm32f4_discovery.h
  group StdPeriph_Driver
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group cmcore
    ../../../cmcore/: armcore.c delay.c gpio.c spibus.c usart.c
