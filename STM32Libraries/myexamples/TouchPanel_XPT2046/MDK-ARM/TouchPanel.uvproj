# Keil uVision project TouchPanel.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: TouchPanel
  c flags: Optim=3 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: ..\..\TouchPanel_XPT2046;..\..\..\CMSIS\Include;..\..\..\CMSIS\STM32F4xx;..\..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\cmcore;..\..\..\cmperiphlib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main Group
    ./: startup_stm32f4xx.s
    ../: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group StdPeriph_Driver
    ../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_spi.c
  group armcore
    ../../../cmcore/: armcore.c armcore.h delay.c gpio.c spistruct.c spistruct.h usart.c usart.h
  group TouchPanel
    ../../../cmperiphlib/TouchPanel/: XPT2046.h XPT2046.c
