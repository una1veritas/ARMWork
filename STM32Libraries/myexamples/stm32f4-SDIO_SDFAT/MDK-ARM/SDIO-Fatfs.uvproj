# Keil uVision project SDIO-Fatfs.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SDIO-Fatfs
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\stm32f4-SDIO_SDFAT;..\..\..\..\STM32Libraries\CMSIS\Include;..\..\..\..\STM32Libraries\CMSIS\STM32F4xx;..\..\..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\STM32Libraries\cmcore
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: main.c stm32f4_discovery.c stm32f4_discovery_sdio_sd.c system_stm32f4xx.c stm32fxxx_it.c diskio.c ff.c
  group stdperiph_driver
    ../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_cryp.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_aes.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c
  group armcore
    ../../../cmcore/: gpio.c delay.c i2c.c spibus.c usart.c armcore.h armcore.c delay.h
