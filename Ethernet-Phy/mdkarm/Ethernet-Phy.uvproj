# Keil uVision project Ethernet-Phy.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Ethernet-Phy
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Ethernet-Phy;..\cmsis_boot;..\Ethernet\include;..\STM32F4x7_ETH_Driver\inc;..\STM32F4x7_ETH_Driver\inc\lwip
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: stm32f4xx_it.c stm32f4_discovery.c main.c
    ../Ethernet/source/: fs.c httpd.c httpd_cgi_ssi.c netconf.c serial_debug.c stm32f4x7_eth_bsp.c
    ../cmsis_boot/: system_stm32f4xx.c
    ../STM32F4x7_ETH_Driver/src/: ethernetif.c stm32f4x7_eth.c
    ../STM32F4x7_ETH_Driver/src/core/: mem.c pbuf.c netif.c tcp.c sys.c stats.c tcp_in.c tcp_out.c udp.c raw.c init.c dns.c dhcp.c memp.c
    ../STM32F4x7_ETH_Driver/src/core/ipv4/: ip.c ip_addr.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip_frag.c
    ../STM32F4x7_ETH_Driver/src/netif/: etharp.c loopif.c slipif.c
    ../STM32F4x7_ETH_Driver/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c randm.c vj.c
  group stdperiph
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
