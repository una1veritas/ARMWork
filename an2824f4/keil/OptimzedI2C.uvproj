# Keil uVision project OptimzedI2C.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: OptimzedI2C
  c flags: Optim=2 oTime=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\stm32library\CMSIS\Include;..\..\stm32library\STM32F4xx_StdPeriph_Driver\inc;..\..\stm32library\CMSIS\STM32F4xx;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: startup_stm32f4xx.s
    ../src/: I2CRoutines.c main.c stm32f4xx_it.c
    ../inc/: I2CRoutines.h stm32f4xx_conf.h stm32f10x_conf.h stm32f30x_it.h
  group stdperiph
    ../../stm32library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_usart.c
