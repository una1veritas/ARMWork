# Keil uVision project stm32f4-stdperiph.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4-stdperiph +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\stm32library\STM32F4xx_StdPeriph_Driver\inc;..\..\stm32library\CMSIS\Include;..\..\stm32library\CMSIS\STM32F4xx;..\..\stm32f4-stdperiph;..\..\stm32library\armcore;..\..\stm32library\armperiphlib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group usermain
    ./: startup_stm32f4xx.s
    ../: main.cpp stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_it.h
  group armcore
    ../../stm32library/armcore/: adc3dma.c adc3dma.h armcore.h binary.h delay.c delay.h gpio.c gpio.h i2c.c i2c.h Print.cpp Print.h Stream.cpp Stream.h systick.c systick.h usart.c usart.h USARTSerial.cpp USARTSerial.h I2CWire.cpp I2CWire.h spi.c spi.h SPIBus.cpp SPIBus.h
  group armperiphlib
    ../../stm32library/armperiphlib/ChLCD/: CharacterLCD.h ST7032i.cpp ST7032i.h
    ../../stm32library/armperiphlib/RTC/: DS1307.cpp DS1307.h
  group stdperiph_driver
    ../../stm32library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_spi.c
    ../../stm32library/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_i2c.h stm32f4xx_spi.h
