# Keil uVision project LPC11U24LCDRFID.uvproj, settings and files
target cappuccino (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11U37_CAPPUCCINO +hex
  c flags: Optim=3 wLevel=2
  c define: ARMCMX  CAPPUCCINO USE_SL030
  c include: ..\..\LPCLibrary\CMSISv2p00_LPC11Uxx;..\..\armcmx\lpc11uxx;..\..\armcmx;..\inc;..\src;..\..\armcmx\tools\LCD;..\..\armcmx\tools\RTC;..\..\armcmx\tools\RFID;..\..\armcmx\tools\TextStream;..\..\armcmx\tools\SDFatFs;..\..\armcmx\tools\SDFatFs\FatFs;..\..\armcmx\tools\SerialRAM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group startup
    ./: startup_LPC11Uxx.s
  group main
    ../src/: main.cpp Task.cpp Task.h nfcreader.cpp
  group cmsis2.0
    ../src/: system_LPC11Uxx.c
    ../../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: core_cm0.c
  group armcmx
    ../../armcmx/lpc11uxx/: gpio.c delay_systick.c i2c.c usart.c PWM0tone.c spi_core.c
    ../../armcmx/: I2CBus.cpp Print.cpp Stream.cpp USARTSerial.cpp SPI.cpp
  group tools
    ../../armcmx/tools/LCD/: ST7032i.cpp
    ../../armcmx/tools/RTC/: RTC.cpp
    ../../armcmx/tools/RFID/: PN532_I2C.cpp StrongLink_I2C.cpp ISO14443.cpp
    ../../armcmx/tools/SDFatFs/: SDFatFs.cpp SDFatFs.h ff.c mmc_ssp.c ssp.c
    ../../armcmx/tools/SerialRAM/: SPISRAM.cpp SPISRAM.h
    ../../armcmx/tools/TextStream/: StringBuffer.cpp StringBuffer.h
