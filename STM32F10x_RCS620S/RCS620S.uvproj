# Keil uVision project RCS620S.uvproj, settings and files
target RCS620S (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RCS620S
  c flags: Optim=1
  c define: STM32F10X_MD ARMCMX USE_STDPERIPH_DRIVER STDSERIAL=2
  c include: ..\STM32Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_Olimexino;..\armcmx\stm32f10x;..\armcmx;..\STM32F10x_Olimexino;..\armcmx\stm32f10x\utility;..\armcmx\tools\RFID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f10x_md.s
  group User
    ./: stm32f10x_it.c system_stm32f10x.c main.cpp
  group stm32_stdperiph_driver
    ../STM32Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group armcmx
    ../armcmx/: armcmx.c Print.cpp Stream.cpp USARTSerial.cpp
    ../armcmx/stm32f10x/: delay.c gpio.c usart.c
    ../armcmx/tools/RFID/: RCS620S.cpp ISO14443.cpp
