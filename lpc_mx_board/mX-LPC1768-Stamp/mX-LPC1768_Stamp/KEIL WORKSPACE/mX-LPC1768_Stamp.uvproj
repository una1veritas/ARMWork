# Keil uVision project mX-LPC1768_Stamp.uvproj, settings and files
target LPC17xx Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: mX-LPC1768_Stamp +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\..\COMMON\INC;..\APP\INC;..\DRIVERS\LCD\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Source
    ../APP/SRC/: main.c
    ../../ADC_UART/DRIVERS/UART/SRC/: uart.c
    ../../ADC_UART/DRIVERS/ADC/SRC/: adc.c
    ../../DAC AUDIO/DRIVERS/DAC/SRC/: dac.c
    ../../EXT INT BUZZER/DRIVERS/EXT_INT/SRC/: extint.c
    ../../I2C EEPROM/DRIVERS/AT24LC256/SRC/: i2c.c
    ../../PS2_UART/DRIVERS/PS2/SRC/: ps2kbd.c
    ../../USB HID/DRIVERS/USB/SRC/: hiduser.c usbcore.c usbdesc.c usbhw.c usbuser.c
    ../../LCD/DRIVERS/LCD/SRC/: lcd.c
  group Startup
    ../../COMMON/SRC/: startup_LPC17xx.s
  group Common
    ../../COMMON/SRC/: system_LPC17xx.c
target LPC17xx RAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBCDC +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x8000
