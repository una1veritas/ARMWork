# Keil uVision project USB HOST.uvproj, settings and files
target LPC17xx Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USB +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\..\COMMON\INC;..\APP\INC;..\DRIVERS\USB_HOST\HOST\INC;..\DRIVERS\USB_HOST\FAT\INC;..\DRIVERS\USB_HOST\MASS_STORAGE\INC;..\DRIVERS\USB_HOST\INCLUDE;..\DRIVERS\USB_HOST\UART\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Source
    ../APP/SRC/: usbhost_main.c lcd.c
    ../DRIVERS/USB_HOST/FAT/SRC/: usbhost_fat.c
    ../DRIVERS/USB_HOST/HOST/SRC/: usbhost_lpc17xx.c
    ../DRIVERS/USB_HOST/MASS_STORAGE/SRC/: usbhost_ms.c
    ../DRIVERS/USB_HOST/UART/SRC/: usbhost_uart.c
  group Startup
    ../../COMMON/SRC/: startup_LPC17xx.s
  group Common
    ../../COMMON/SRC/: system_LPC17xx.c
target LPC17xx RAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBCDC +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x8000
