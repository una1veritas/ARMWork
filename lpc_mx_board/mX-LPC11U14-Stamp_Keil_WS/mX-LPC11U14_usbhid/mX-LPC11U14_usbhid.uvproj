# Keil uVision project mX-LPC11U14_usbhid.uvproj, settings and files
target USBHID_Release (ARM-ADS)
  device: LPC1114x302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: mX-LPC11U14_usbhid +hex
  AfterMake: fromelf --bin .\obj\mX-LPC11U14_usbhid.axf -o .\obj\mX-LPC11U14_usbhid.bin
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc;.\USBDriver\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source
    ./: hiduser.c usbdesc.c usbuser.c io_event.c mX-LPC11U14_usbhid.c
    ./USBDriver/src/: usbcore.c usbhw.c
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group Common
    ../Common/src/: timer16.c
