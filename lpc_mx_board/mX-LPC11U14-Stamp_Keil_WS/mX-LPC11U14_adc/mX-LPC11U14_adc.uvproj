# Keil uVision project mX-LPC11U14_adc.uvproj, settings and files
target Blinky_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NGX_keil_adc_11U14 +hex
  AfterMake: fromelf --bin .\obj\NGX_keil_adc_11U14.axf -o .\obj\NGX_keil_adc_11U14.bin
  c flags: Optim=1
  c define: __DEBUG_RAM
  c include: .;..\Common\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1c00
  memory RVCT9: RAM 0x10001c00 size 0x400
  group Source
    ./: mX-LPC11U14_adc.c
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group Common
    ../Common/src/: clkconfig.c gpio.c nmi.c lcd.c lpc11xx_adc.c lpc11xx_syscon.c Simple_ADC.c
target Blinky_Release (ARM-ADS)
  device: LPC1114x302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: mX-LPC11U14_adc +hex
  AfterMake: fromelf --bin .\obj\mX-LPC11U14_adc.axf -o .\obj\mX-LPC11U14_adc.bin
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
