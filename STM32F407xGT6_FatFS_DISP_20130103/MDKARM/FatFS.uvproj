# Keil uVision project FatFS.uvproj, settings and files
target FatFS Test (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: FatFS
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\STM32Libraries\CMSIS\Include;..\..\STM32Libraries\CMSIS\STM32F4xx;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\lib\ff;..\lib\display\abstract\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group Main
    ./: startup_stm32f4xx.s
    ../src/: main.c hw_config.c rtc_support.c ff_support.c stm32f4xx_it.c syscalls.c system_stm32f4xx.c systick.c term_io.c uart_support.c xprintf.c
    ../inc/: hw_config.h ff_support.h rtc_support.h platform_config.h stm32f4xx_conf.h stm32f4xx_it.h syscalls_if.h systick.h term_io.h uart_support.h xprintf.h
  group stdperiph
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_hash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
