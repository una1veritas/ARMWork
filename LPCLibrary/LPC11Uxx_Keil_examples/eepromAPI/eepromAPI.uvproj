# Keil uVision project eepromAPI.uvproj, settings and files
target eepromAPI_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: eepromAPI +hex
  c flags: Optim=1
  c define: __DEBUG_RAM
  c include: ..\common\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1c00
  memory RVCT9: RAM 0x10001c00 size 0x400
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group Source
    ./: eepromAPItest.c eepromAPI.c
  group Common
    ../Common/src/: uart.c
  group Documentation
    ./: Read-me.txt
target eepromAPI_Release (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: eepromAPI +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: ..\Common\inc
  asm define: NO_CRP
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
