# Keil uVision project DivTest.uvproj, settings and files
target DivTest (ARM-ADS)
  device: LPC11U24/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x100017FF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DivTest +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: ..\Common\inc;..\USBROMDriver\comps\mw_usbd;..\USBROMDriver\comps\mw_common;..\USBROMDriver\USB_HID\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1800
  link misc: --verbose --list=LINK_DETAIL.txt
  group Source
    ./: Main.c
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group Common
    ../Common/src/: uart.c
  group Documentation
    ./: Readme.txt
