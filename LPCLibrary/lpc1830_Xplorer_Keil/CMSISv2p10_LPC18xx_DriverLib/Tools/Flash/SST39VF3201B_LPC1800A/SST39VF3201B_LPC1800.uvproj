# Keil uVision project SST39VF3201B_LPC1800.uvproj, settings and files
target SST39VF3201B_LPC1800 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SST39VF3201B_LPC1800A
  AfterMake: cmd.exe /C copy SST39VF3201B_LPC1800A.axf ..\SST39VF3201B_LPC1800A.FLM
  c flags: Optim=3
  c define: CORE_M3
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c core_cm3.c system_LPC18xx.c scu.c
  group Device Description
    ./: FlashDev.c
