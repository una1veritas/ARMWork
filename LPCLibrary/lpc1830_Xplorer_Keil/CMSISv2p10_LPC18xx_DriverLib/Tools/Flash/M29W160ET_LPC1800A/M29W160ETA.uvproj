# Keil uVision project M29W160ETA.uvproj, settings and files
target M29W160ET (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: M29W160ET_LPC1800A
  AfterMake: cmd.exe /C copy M29W160ET_LPC1800A.axf ..\M29W160ET_LPC1800A.FLM
  c flags: Optim=3
  c define: CORE_M3
  c include: C:\Keil\ARM\Flash
  scatter file: .\Target.lin
  link misc: --entry 1
  group Program Functions
    ./: FlashPrg.c core_cm3.c system_LPC18xx.c scu.c
  group Device Description
    ./: FlashDev.c
