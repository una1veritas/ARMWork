# Keil uVision project LPC1830_Xplorer_Sdcard.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1830_Xplorer_Sdcard +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M3
  c include: ..\..\..\Core\CMSIS\Include;..\..\..\Core\Device\NXP\LPC18xx\Include;..\..\CMSISv2p10_LPC18xx_DriverLib\inc;..\..\Adc_Interrupt;..\..\LPC1830_Xplorer_UsbVcomLib\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ../../CMSISv2p10_LPC18xx_DriverLib/Core/Device/NXP/LPC18xx/Source/Templates/ARM/: startup_LPC18xx.s
  group CMSIS-CM3
    ../../CMSISv2p10_LPC18xx_DriverLib/Core/Device/NXP/LPC18xx/Source/Templates/: system_LPC18xx.c
  group Drivers
    ../../CMSISv2p10_LPC18xx_DriverLib/src/: debug_frmwrk.c lpc18xx_cgu.c lpc18xx_scu.c lpc18xx_uart.c lpc18xx_timer.c lpc18xx_sdif.c lpc18xx_sdmmc.c lpc18xx_gpio.c lpc18xx_utils.c
  group Usb1_vcom
    ../../LPC1830_Xplorer_UsbVcomLib/src/: vcomdemo.c usbuser.c usbhw.c usbdesc.c usbcore.c serial.c cdcuser.c
  group Main
    ../: Main.c
  group Readme
    ../: abstract.txt
target SPIFI 32MB Debug (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: as above
  output: LPC1830_Xplorer_Sdcard +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3
  c define: CORE_M3
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x14000000 size 0x100000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
