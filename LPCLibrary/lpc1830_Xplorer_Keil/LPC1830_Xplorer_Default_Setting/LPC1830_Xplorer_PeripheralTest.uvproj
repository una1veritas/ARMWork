# Keil uVision project LPC1830_Xplorer_PeripheralTest.uvproj, settings and files
target SPIFI 32MB Debug (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1830_Xplorer_PeripheralTest +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M3
  c include: ..\..\CMSISv2p10_LPC18xx_DriverLib\Core\CMSIS\Include;..\..\CMSISv2p10_LPC18xx_DriverLib\Core\Device\NXP\LPC18xx\Include;..\..\CMSISv2p10_LPC18xx_DriverLib\inc;..\..\LPC1830_Xplrer_UsbVcomLib\inc;..\EMAC\inc;..\Common\inc;..\Audio_loopback\inc;..\HID\usbd
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x14000000 size 0x100000
  memory RVCT9: RAM 0x10080000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
