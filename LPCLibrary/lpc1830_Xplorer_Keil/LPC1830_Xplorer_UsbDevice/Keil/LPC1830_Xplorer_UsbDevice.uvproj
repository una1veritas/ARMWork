# Keil uVision project LPC1830_Xplorer_UsbDevice.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1830_Xplorer_UsbDevice +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M3
  c include: ..\..\..\Core\CMSIS\Include;..\..\..\Core\Device\NXP\LPC18xx\Include;..\..\CMSISv2p10_LPC18xx_DriverLib\inc;..\Usb_MassStorage\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ../../CMSISv2p10_LPC18xx_DriverLib/Core/Device/NXP/LPC18xx/Source/Templates/ARM/: startup_LPC18xx.s
  group CMSIS-CM3
    ../../CMSISv2p10_LPC18xx_DriverLib/Core/Device/NXP/LPC18xx/Source/Templates/: system_LPC18xx.c
  group Source code
    ../../CMSISv2p10_LPC18xx_DriverLib/src/: lpc18xx_cgu.c lpc18xx_scu.c lpc18xx_uart.c
  group Usb_dev
    ../Usb_MassStorage/src/: usbuser.c usbhw.c usbdesc.c mscuser.c usbcore.c DiskImg.c
  group Main
    ../: Main.c
  group Readme
    ../: Abstract.txt
