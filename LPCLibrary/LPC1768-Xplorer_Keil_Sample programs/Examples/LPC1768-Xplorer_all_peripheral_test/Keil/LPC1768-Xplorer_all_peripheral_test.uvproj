# Keil uVision project LPC1768-Xplorer_all_peripheral_test.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1768-Xplorer_all_peripheral_test +hex
  c flags: Optim=3
  c include: ..\..\CMSISv1p30_LPC17xx\Core\Device\NXP\LPC17xx\Include;..\..\CMSISv1p30_LPC17xx\inc;..\EMAC\inc;..\Common\inc
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ../../../Core/Device/NXP/LPC17xx/Source/Templates/ARM/: startup_LPC17xx.s
  group System Code
    ../../LPC1768-Xplorer_ethernet/: system_LPC17xx.c
  group Drivers
    ../../../Drivers/src/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_timer.c timer_utilitis.c i2c.c lpc1768_sd.c lpc1768_spi.c rtc.c sd.c ssp.c lpc17xx_uart.c
  group Main
    ../: main.c
  group usb_vcom
    ../../../USB_VCOM/src/: cdcuser.c serial.c usbcore.c usbdesc.c usbhw.c usbuser.c vcomdemo.c
  group Documentation
    ../: Abstract.txt
  group EMAC
    ../EMAC/src/: easyweb.c
    ../../LPC1768-Xplorer_ethernet/src/: ethmac.c ew_systick.c tcpip.c
  group Common
    ../../../Common/src/: delay.c
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LPC1768-Xplorer_all_peripheral_test +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3
  c include: ..\EMAC\inc;..\..\..\Core\Device\NXP\LPC17xx\Include;..\..\..\Common\inc;..\..\..\Drivers\inc;..\..\LPC1768-Xplorer_ethernet\inc
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
