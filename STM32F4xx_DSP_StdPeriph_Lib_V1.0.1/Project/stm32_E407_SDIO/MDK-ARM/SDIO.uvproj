# Keil uVision project SDIO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SDIO +hex
  c flags: Optim=2 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\uSDCard;..\..\..\..\stm32library\CMSIS\Include;..\..\..\..\stm32library\CMSIS\STM32F4xx;..\..\..\..\stm32library\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: startup_stm32f4xx.s
    ../uSDCard/: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h stm32f4xx_it.h stm32f4xx_flash.ld readme.txt
  group stdperiph
    ../../../../stm32library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group board
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_sdio_sd.c stm324xg_eval_sdio_sd.h
    ./: stm324xg_eval.h
