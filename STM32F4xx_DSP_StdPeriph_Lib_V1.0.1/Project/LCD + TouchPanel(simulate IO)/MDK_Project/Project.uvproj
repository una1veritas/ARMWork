# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\User;..\Lib\cmsis;..\Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c
  group LCD
    ../User/LCD/: AsciiLib.c LCD.c
  group SysTick
    ../User/SysTick/: stm32f10x_systick.c systick.c
  group TouchPanel
    ../User/TouchPanel/: TouchPanel.c
  group StdPeriph_Driver
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_fsmc.c misc.c stm32f10x_spi.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c
    ../User/: system_stm32f10x.c
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_cl.s
