# Keil uVision project Project.uvproj, settings and files
target STM32F4 Discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4Discovery
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STM32F4_DISCOVERY, STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\..\STM32Libraries\CMSIS\STM32F4xx;..\..\..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\STM32Libraries\cmcore\Boards;..\..\..\..\STM32Libraries\cmcore;..\..\..\..\STM32Libraries\cmperiphlib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../: stm32f4xx_it.c main.c main.h PCD8544.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_lcd.c stm324xg_eval.c stm324xg_eval_fsmc_sram.c stm324xg_eval_ioe.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_cryp_des.c stm32f4xx_cryp.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_aes.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_sdio.c
  group CMSIS
    ../../../../STM32Libraries/CMSIS/STM32F4xx/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group cmperiphlib
    ../../../../STM32Libraries/cmcore/Boards/: stm32f4_discovery.h
  group cmcore
    ../../../../STM32Libraries/cmcore/: gpio.c delay.c usart.c gpio.h spibus.c
