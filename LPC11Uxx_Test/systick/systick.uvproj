# Keil uVision project systick.uvproj, settings and files
target Systick_Debug (ARM-ADS)
  device: LPC11U24/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x100017FF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: systick +hex
  c flags: Optim=1 OneElfS=1
  c define: __DEBUG_RAM
  c include: .;..\Common\inc;..\..\LPCLibrary\armcmx\lpc11uxx;..\..\LPCLibrary\armcmx
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1800
  group Source
    ./: systicktest.c
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group Common
    ../Common/src/: gpio.c
  group Documentation
    ./: Read-me.txt
  group armcmx
    ../../LPCLibrary/armcmx/lpc11uxx/: delay.c
target Systick_Release (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: systick +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc;..\..\LPCLibrary\armcmx;..\..\LPCLibrary\armcmx\lpc11uxx
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
