# Keil uVision project LPC11U37LCD.uvproj, settings and files
target 11U37 (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11U37LCD +hex
  c flags: Optim=1 wLevel=2
  c define: ARMCMX
  c include: ..\src;..\..\..\LPCLibrary\CMSISv2p00_LPC11Uxx;..\..\..\armcmx\lpc11uxx;..\..\..\armcmx;..\..\..\armcmx\tools\LCD;..\..\..\armcmx\tools\TextStream
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group startup
    ./: startup_LPC11Uxx.s
  group main
    ../src/: main.cpp
  group cmsis2.0
    ../../../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: core_cm0.c system_LPC11Uxx.c
  group armcmx
    ../../../armcmx/lpc11uxx/: delay_systick.c gpio.c i2c.c usart.c
    ../../../armcmx/: I2CBus.cpp Print.cpp USARTSerial.cpp Stream.cpp
    ../../../armcmx/tools/LCD/: ST7032i.cpp
    ../../../armcmx/tools/TextStream/: StringStream.cpp
