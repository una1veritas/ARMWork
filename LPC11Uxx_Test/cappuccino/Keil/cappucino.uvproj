# Keil uVision project cappucino.uvproj, settings and files
target cappucino test (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: cappucino
  c flags: Optim=1
  c include: .\;..\inc;..\..\..\LPCLibrary\CMSISv2p00_LPC11Uxx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group startup
    ./: startup_LPC11Uxx.s
  group src
    ../src/: main.c ff.c gpio.c i2c.c i2clcd.c l6470.c mmc_ssp.c sd.c ssp.c systick.c uart.c xprintf.c
  group CMSIS2.0
    ../../../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: system_LPC11Uxx.c core_cm0.c
