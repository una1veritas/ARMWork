# Keil uVision project PMW.uvproj, settings and files
target PWM_Debug (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: pwmtest +hex
  c flags: Optim=1 OneElfS=1
  c define: __DEBUG_RAM
  c include: ..\PWM;..\..\LPCLibrary\armcmx\lpc11uxx;..\..\LPCLibrary\armcmx
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group Source
    ./: PWM16test.c
  group Startup
    ../Common/src/: core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s
  group Documentation
    ./: Read-me.txt
  group armcmx
    ../../LPCLibrary/armcmx/lpc11uxx/: gpio.c delay_systick.c PWM0tone.c
target PWM_Release (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: PWMtest +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
