# Keil uVision project USBCDC.uvproj, settings and files
target LPC11Uxx_IFLASH (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: USBCDC +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: ..\;..\..\LPCLibrary\armcmx\lpc11uxx;..\..\LPCLibrary\armcmx\;..\..\LPCLibrary\LPC11Uxx_USBDriver
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source
    ../: main.c cdcuser.c usbdesc.c usbuser.c
    ../../LPCLibrary/LPC11Uxx_USBDriver/: usbcore.c usbhw.c
  group Startup
    ./: startup_LPC11Uxx.s
  group Common
    ../../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: core_cm0.c system_LPC11Uxx.c
  group Documentation
    ../: Abstract.txt
  group armcmx
    ../../LPCLibrary/armcmx/lpc11uxx/: delay.c gpio.c spi.c ssp.c usart.c
