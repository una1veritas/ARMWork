# Keil uVision project Buzz.uvproj, settings and files
target lpclcd (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11U24SPI
  c flags: Optim=3 OneElfS=1
  c define: ARMCMX
  c include: ..\..\LPCLibrary\CMSISv2p00_LPC11Uxx\inc;..\..\LPCLibrary\armcmx\lpc11uxx;..\..\LPCLibrary\armcmx;..\..\STM32Libraries\armcmxtools\SerialRAM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group startup
    ./: startup_LPC11Uxx.s
  group main
    ./: main.cpp
  group CMSIS
    ../../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: core_cm0.c system_LPC11Uxx.c
  group armcmx
    ../../LPCLibrary/armcmx/lpc11uxx/: clkconfig.c gpio.c i2c.c nmi.c usart.c ssp.c spi.c delay_systick.c
    ../../LPCLibrary/armcmx/: SPIBus.cpp SPIBus.h Print.cpp Stream.cpp USARTSerial.cpp
    ../../STM32Libraries/armcmxtools/SerialRAM/: SPISRAM.cpp SPISRAM.h
