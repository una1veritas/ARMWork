# Keil uVision project USART_DMA_Interrupt.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART_DMA_Interrupt
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: ..\DMA_Interrupt;..\..\STM32Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group StdPeriph_Driver
    ../../STM32Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
