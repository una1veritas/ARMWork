# Keil uVision project GPIO_IOToggle.uvproj, settings and files
target GPIO_IOToggle (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")ESEL ELITTLE FPU2
  output: GPIO_IOToggle
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: ARMCMX USE_STDPERIPH_DRIVER STM32F30X STDSERIAL=3
  c include: .\..\;..\..\STM32Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\STM32Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\STM32Libraries\Utilities\STM32F3_Discovery;..\..\armcmx;..\..\armcmx\stm32f30x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDK-ARM
    ../../STM32Libraries/CMSIS/STM32F30x/startup/arm/: startup_stm32f30x.s
  group STM32F3-Discovery
    ../../STM32Libraries/Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ../../STM32Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_exti.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group User
    ./../: main.c stm32f30x_it.c system_stm32f30x.c
  group armcmx
    ../../armcmx/stm32f30x/: gpio.c systick.c delay.c usart.c
    ../../armcmx/: armcmx.c
