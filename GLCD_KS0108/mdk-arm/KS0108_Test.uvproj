# Keil uVision project KS0108_Test.uvproj, settings and files
target KS0108_Test (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SSD1289
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, F4DISCOVERY, STM32F4XX
  c include: ..\;..\KS0108;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Libraries\cmcore;..\..\STM32Libraries\cmcore\utility
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group main
    ./: startup_stm32f4xx.s
    ../: stm32f4xx_it.c stm32f4xx_conf.h main.cpp
    ../../STM32Libraries/cmcore/utility/: system_stm32f4xx.c
    ../avr/: io.h
  group StdPeriph
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group cmcore
    ../../STM32Libraries/cmcore/: delay.c cmcore.c gpio.c usart.c
  group KS0108
    ../KS0108/: glcd.cpp glcd.h glcd_Buildinfo.h glcd_Config.h glcd_Device.cpp gText.cpp
    ../KS0108/include/: stm32f4xx_glcd_io.h
