# Keil uVision project GLCD_KS0108.uvproj, settings and files
target KS0108 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: GLCD_KS0108
  c flags: Optim=2 OneElfS=1
  c define: STM32F4 USE_STDPERIPH_DRIVER HSE_VALUE=8000000
  c include: ..\..\GLCD_KS0108;..\..\STM32Libraries\cmcore;..\..\STM32Libraries\cmcore\utility;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: startup_stm32f4xx.s
    ../: glcd.cpp glcd_Device.cpp gText.cpp main.cpp
    ../../STM32Libraries/cmcore/utility/: stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_it.h stm32f4xx_conf.h stm32f4_discovery.h
    ../include/: avrio_.h arduino_io.h glcd_io.h stm32f4xx_io.h
  group cmcore
    ../../STM32Libraries/cmcore/: cmcore.c cmcore.h delay.c delay.h gpio.c gpio.h Print.cpp Print.h usart.c usart.h
    ../../STM32Libraries/cmcore/utility/: stdiodef.c stdiodef.h
