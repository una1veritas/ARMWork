# Keil uVision project Project.uvproj, settings and files
target STM32100E-EVAL (ARM-ADS)
  device: STM32F100ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD_VL, USE_STM32100E_EVAL
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc;..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F10x;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM32100E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STM32_CPAL_Driver
    ../../../../../Libraries/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
  group Common
    ../../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c
    ../../../../../Utilities/STM32_EVAL_CPAL/Common/: stm32_eval_i2c_ee_cpal.c stm32_eval_i2c_tsensor_cpal.c
  group STM32F10x
    ../../../../../Utilities/STM32_EVAL_CPAL/STM32100E_EVAL/: stm32100e_eval_ioe_cpal.c
    ../../../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval.c stm32100e_eval_lcd.c
    ../../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c stm3210c_eval.c
    ../../../../../Utilities/STM32_EVAL_CPAL/STM3210C_EVAL/: stm3210c_eval_ioe_cpal.c
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
    ../: system_stm32f10x.c
    ../../../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd_vl.s startup_stm32f10x_cl.s
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32F2xx
    ../../../../../Utilities/STM32_EVAL_CPAL/STM322xG_EVAL/: stm322xg_eval_ioe_cpal.c
    ../../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c stm322xg_eval.c
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f2xx/: cpal_i2c_hal_stm32f2xx.c
    ../: system_stm32f2xx.c
    ../../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_syscfg.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_usart.c stm32f2xx_tim.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_pwr.c
    ../../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group STM32F4xx
    ../../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c
    ../../../../../Utilities/STM32_EVAL_CPAL/STM3240_41_G_EVAL/: stm324xg_eval_ioe_cpal.c
    ../../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../: system_stm32f4xx.c
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f4xx/: cpal_i2c_hal_stm32f4xx.c
    ../../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_syscfg.c
  group User
    ../: main.c demo.c cpal_usercallback.c stm32_it.c
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc;..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F10x;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM3210C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM322xG_EVAL (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F2XX, USE_STM322xG_EVAL
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc;..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F2xx;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM322xG_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM324xG_EVAL (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, USE_STM324xG_EVAL
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc;..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F4xx;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common;..\..\..\..\..\Utilities\STM32_EVAL_CPAL\STM3240_41_G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
