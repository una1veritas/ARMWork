# IAR project Project.ewp, settings and files
configuration STM3210C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F10x; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32100E_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD_VL; USE_STM32100E_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F10x; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common
configuration STM32L152_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32L1xx; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
configuration STM322xG_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F2xx; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
configuration STM324xG_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32F4xx; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
configuration STM32L152D_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\devices\STM32L1xx; ..\..\..\..\..\Libraries\STM32_CPAL_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL_CPAL\Common
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  group STM32_CPAL_Driver
    ../../../../../Libraries/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
  group STM32_EVAL
    ../../../../../Utilities/STM32_EVAL_CPAL/Common/: stm32_eval_i2c_ee_cpal.c
  group STM32F10x/CMSIS
    ../../../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd_vl.s
    ../: system_stm32f10x.c
  group STM32F10x/CPAL_HAL
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
  group STM32F10x/STM32100E_EVAL
    ../../../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval.c stm32100e_eval_lcd.c
  group STM32F10x/STM3210C_EVAL
    ../../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_lcd.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32F2xx/CMSIS
    ../../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    ../: system_stm32f2xx.c
  group STM32F2xx/CPAL_HAL
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f2xx/: cpal_i2c_hal_stm32f2xx.c
  group STM32F2xx/STM322xG_EVAL
    ../../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_lcd.c
  group STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group STM32F4xx/CMSIS
    ../../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    ../: system_stm32f4xx.c
  group STM32F4xx/CPAL_HAL
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32f4xx/: cpal_i2c_hal_stm32f4xx.c
  group STM32F4xx/STM324xG_EVAL
    ../../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group STM32L1xx/CMSIS
    ../../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s
    ../: system_stm32l1xx.c
  group STM32L1xx/CPAL_HAL
    ../../../../../Libraries/STM32_CPAL_Driver/devices/stm32l1xx/: cpal_i2c_hal_stm32l1xx.c
  group STM32L1xx/STM32L152_EVAL
    ../../../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c stm32l152_eval_lcd.c
  group STM32L1xx/STM32L152D_EVAL
    ../../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_lcd.c
  group STM32L1xx/STM32L1xx_StdPeriph_Driver
    ../../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group User
    ../: cpal_usercallback.c main.c stm32_it.c
