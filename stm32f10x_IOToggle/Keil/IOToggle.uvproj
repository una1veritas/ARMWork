# Keil uVision project IOToggle.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IOToggle
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD ARMCMX USE_STDPERIPH_DRIVER CPAL_USE_I2C1
  c include: ..\..\STM32F10x_IOToggle;..\..\armcmx\stm32f10x;..\..\armcmx;..\..\STM32Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\armcmx\stm32f10x\utility;..\..\armcmx\stm32f10x\CPAL;..\..\STM32Libraries\STM32_CPAL_Driver\devices\stm32f10x;..\..\STM32Libraries\STM32_CPAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../../STM32Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group User
    ../../STM32Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
    ../: main.c stm32f10x_it.c
  group StdPeriph
    ../../STM32Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group armcmx
    ../../armcmx/: armcmx.c
    ../../armcmx/stm32f10x/: delay.c gpio.c usart.c i2c_cpal.c i2c_cpal.h
    ../../armcmx/stm32f10x/CPAL/: cpal_i2c.c cpal_i2c_hal_stm32f10x.c cpal_hal.c cpal_usercallback.c
