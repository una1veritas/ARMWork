# Keil uVision project LPC11U24LCDRFID.uvproj, settings and files
target lpclcdrfid (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11U24LCDRFID +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin "#L" -o "$Pfirmware.bin"
  AfterMake: C:\nxp\LPCXpresso_5.2.4\lpcxpresso\bin\checksum -p LPC11U24_401 -d "$Pfirmware.bin"
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: ARMCMX
  c include: ..\..\LPCLibrary\CMSISv2p00_LPC11Uxx;..\..\LPCLibrary\armcmx\lpc11uxx;..\..\LPCLibrary\armcmx;..\inc;..\src;..\..\STM32Libraries\armcmxtools\LCD;..\..\STM32Libraries\armcmxtools\RTC;..\..\STM32Libraries\armcmxtools\RFID
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group startup
    ./: startup_LPC11Uxx.s
  group main
    ../src/: main.cpp nfc.cpp
  group cmsis2.0
    ../src/: system_LPC11Uxx.c
    ../../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: core_cm0.c
  group armcmx
    ../../LPCLibrary/armcmx/lpc11uxx/: gpio.c gpio.h i2c.c i2c.h LPC11Uxx.h nmi.c nmi.h power_api.h usart.c usart.h delay.h delay.c timer16.h type.h
    ../../LPCLibrary/armcmx/: armcmx.h USARTSerial.cpp USARTSerial.h Stream.h Stream.cpp Print.h Print.cpp I2CBus.cpp I2CBus.h
  group tools
    ../../STM32Libraries/armcmxtools/LCD/: HD44780.h ST7032i.cpp ST7032i.h
    ../../STM32Libraries/armcmxtools/RFID/: ISO14443.h PN532_I2C.cpp PN532_I2C.h
    ../../STM32Libraries/armcmxtools/RTC/: DS1307.cpp DS1307.h
