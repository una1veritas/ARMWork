# Keil uVision project STM32F4Player.uvproj, settings and files
target STM32F4Player (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4Player
  c flags: Optim=1 OneElfS=1
  c include: ..\;..\..\ChibiOS_2.4.3\os\kernel\include;..\..\ChibiOS_2.4.3\os\ports\RVCT\ARMCMx;..\..\ChibiOS_2.4.3\os\ports\RVCT\ARMCMx\STM32F4xx;..\..\ChibiOS_2.4.3\os\ports\common\ARMCMx;..\..\ChibiOS_2.4.3\os\hal\include;..\..\ChibiOS_2.4.3\boards\ST_STM32F4_DISCOVERY;..\..\ChibiOS_2.4.3\os\hal\platforms\STM32F4xx;..\..\ChibiOS_2.4.3\os\hal\platforms\STM32;..\..\ChibiOS_2.4.3\os\hal\platforms\STM32\GPIOv2;..\..\ChibiOS_2.4.3\os\various;..\CLCD_QVGA
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: codec_CS43L22.c drawingApp.c main.c uitests.c wavePlayer.c xprintf.c chconf.h codec.h drawingApp.h halconf.h mcuconf.h wavePlayer.h xprintf.h
  group CLCD_QVGA
    ../CLCD_QVGA/: CLCDQVGA_Driver.c CLCDQVGA_Driver.h fonts.c fonts.h keys.c keys.h UI.c UI.h
  group ChibiOS
    ../../ChibiOS_2.4.3/os/ports/RVCT/ARMCMx/: chcore.c chcore.h chcore_v6m.c chcore_v6m.h chcore_v7m.c chcore_v7m.h chtypes.h
    ../../ChibiOS_2.4.3/os/ports/RVCT/ARMCMx/STM32F4xx/: cmparams.h
