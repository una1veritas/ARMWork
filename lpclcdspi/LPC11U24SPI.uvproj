# Keil uVision project LPC11U24SPI.uvproj, settings and files
target lpclcdspi (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11U24SPI
  c flags: Optim=1
  c include: ..\LPCLibrary\CMSISv2p00_LPC11Uxx\inc;..\LPCLibrary\armcmx\lpc11uxx;..\LPCLibrary\armcmx;..\STM32Libraries\armcmxtools\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group startup
    ./: startup_LPC11Uxx.s
  group main
    ./: main.c
  group CMSIS
    ../LPCLibrary/CMSISv2p00_LPC11Uxx/src/: core_cm0.c system_LPC11Uxx.c
  group armcmx
    ../LPCLibrary/armcmx/lpc11uxx/: clkconfig.c delay.c gpio.c i2c.c nmi.c usart.c i2c.h gpio.h type.h usart.h spi.h ssp.c ssp.h spi.c
    ../LPCLibrary/armcmx/: I2CBus.cpp Print.cpp Stream.cpp USARTSerial.cpp SPIBus.cpp SPIBus.h armcmx.h
