# Keil uVision project WebServer.uvproj, settings and files
target WebServer (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: WebServer
  c flags: Optim=1
  c include: ..;..\..\..\..\Ethernet;..\..\..\..\..\armcore;..\..\..\..\..\..\Maple_library\wirish\include;..\..\..\..\..\..\Maple_library\libmaple\include;..\..\..\..\..\..\Maple_library\libmaple\stm32f2\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: startup_stm32f4xx.s
    ../: main.cpp
  group armperiph
    ../../../: Ethernet.cpp Ethernet.h EthernetClient.cpp EthernetClient.h EthernetServer.cpp EthernetServer.h EthernetUdp.cpp EthernetUdp.h IPAddress.cpp IPAddress.h Server.h Udp.h util.h Dns.h Dns.cpp Dhcp.h Dhcp.cpp Client.h
    ../../../utility/: socket.cpp socket.h w5100.cpp w5100.h w5100_config.h
  group maple
    ../../../../../../Maple_library/wirish/: boards_private.h
    ../../../../../../Maple_library/wirish/include/wirish/: WProgram.h wirish_types.h wirish_time.h wirish_math.h wirish_debug.h wirish.h usb_serial.h pwm.h Print.h io.h HardwareTimer.h HardwareSPI.h HardwareSerial.h ext_interrupts.h boards.h bits.h bit_constants.h
