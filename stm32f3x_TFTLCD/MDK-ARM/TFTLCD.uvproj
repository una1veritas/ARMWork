# Keil uVision project TFTLCD.uvproj, settings and files
target TFTLCD (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")ESEL ELITTLE FPU2
  output: TFTLCD
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: ARMCMX USE_STDPERIPH_DRIVER STM32F30X
  c include: .\..\;..\..\STM32Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\STM32Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\STM32Libraries\Utilities\STM32F3_Discovery;..\..\armcmx;..\..\armcmx\stm32f30x;..\..\armcmx\tools\TFTLCD;..\..\armcmx\tools\Adafruit_GFX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDK-ARM
    ../../STM32Libraries/CMSIS/STM32F30x/startup/arm/: startup_stm32f30x.s
  group STM32F3-Discovery
    ../../STM32Libraries/Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ../../STM32Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_exti.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group User
    ./../: stm32f30x_it.c system_stm32f30x.c
    ../: main.cpp
  group armcmx
    ../../armcmx/stm32f30x/: gpio.c systick.c delay.c usart.c
    ../../armcmx/: Print.cpp armcmx.c Stream.cpp USARTSerial.cpp
  group tools
    ../../armcmx/tools/Adafruit_GFX/: Adafruit_GFX.cpp Adafruit_GFX.h
    ../../armcmx/tools/TFTLCD/: TFTLCD.cpp TFTLCD.h
