# IAR project RTC_Calendar.ewp, settings and files
configuration RTC_Calendar (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F3_Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTC_Calendar.srec
  ILINK.IlinkOutputFile: RTC_Calendar.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
  group STM32F3-Discovery
    ../../../../Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_dac.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_wwdg.c
  group User
    ../: main.c stm32f30x_it.c system_stm32f30x.c
