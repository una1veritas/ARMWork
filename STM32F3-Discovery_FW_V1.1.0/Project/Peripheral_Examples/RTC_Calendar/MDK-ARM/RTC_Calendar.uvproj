# Keil uVision project RTC_Calendar.uvproj, settings and files
target RTC_Calendar (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")ESEL ELITTLE FPU2
  output: RTC_Calendar
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: .\..\;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F3_Discovery;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group STM32F3-Discovery
    ./../../../../Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ./../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_dac.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_wwdg.c
  group User
    ./../: main.c stm32f30x_it.c system_stm32f30x.c
