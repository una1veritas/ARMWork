<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TIM_Rettrigreable_OPM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


