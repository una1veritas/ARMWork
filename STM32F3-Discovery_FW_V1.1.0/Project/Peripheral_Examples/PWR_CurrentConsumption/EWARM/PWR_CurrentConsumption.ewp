# IAR project PWR_CurrentConsumption.ewp, settings and files
configuration PWR_CurrentConsumption (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F3_Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWR_CurrentConsumption.srec
  ILINK.IlinkOutputFile: PWR_CurrentConsumption.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
  group STM32F3-Discovery
    ../../../../Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_syscfg.c
  group User
    ../: main.c stm32f30x_it.c stm32f30x_lp_modes.c system_stm32f30x.c
