<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_Example\EWARM\ADC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\CRC_8BitsMessage\EWARM\CRC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DAC_SignalGenerations\EWARM\DAC_SignalGenerations.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_FLASH_RAM\EWARM\DMA_FLASH_RAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_RAM_DAC\EWARM\DMA_RAM_DAC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\EXTI_Example\EWARM\EXTI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_Program\EWARM\FLASH_Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FPU_Example\EWARM\FPU.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\GPIO_IOToggle\EWARM\GPIO_IOToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IWDG_Reset\EWARM\IWDG_Reset.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\OPAMP_PGA\EWARM\OPAMP_PGA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_CurrentConsumption\EWARM\PWR_CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STANDBY\EWARM\PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STOP\EWARM\PWR_STOP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RCC_Example\EWARM\RCC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Demonstration\EWARM\Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RTC_Calendar\EWARM\RTC_Calendar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RTC_Tamper\EWARM\RTC_Tamper.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\Systick_Example\EWARM\SysTick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_Asymetric\EWARM\TIM_Asymetric.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_Combined\EWARM\TIM_Combined.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_ComplementarySignals\EWARM\TIM_ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWM_Input\EWARM\TIM_PWM_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_Rettrigreable_OPM\EWARM\TIM_Rettrigreable_OPM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_TimeBase\EWARM\TIM_TimeBase.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\USB_Example\EWARM\USB_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\WWDG_Example\EWARM\WWDG.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>ADC_Example</project>
        <configuration>ADC_Example</configuration>
      </member>
      <member>
        <project>CRC_8BitsMessage</project>
        <configuration>CRC_8BitsMessage</configuration>
      </member>
      <member>
        <project>DAC_SignalGenerations</project>
        <configuration>DAC_SignalGenerations</configuration>
      </member>
      <member>
        <project>DMA_FLASH_RAM</project>
        <configuration>DMA_FLASH_RAM</configuration>
      </member>
      <member>
        <project>DMA_RAM_DAC</project>
        <configuration>DMA_RAM_DAC</configuration>
      </member>
      <member>
        <project>EXTI_Example</project>
        <configuration>EXTI_Example</configuration>
      </member>
      <member>
        <project>FLASH_Program</project>
        <configuration>FLASH_Program</configuration>
      </member>
      <member>
        <project>FPU_Example</project>
        <configuration>FPU_Example</configuration>
      </member>
      <member>
        <project>GPIO_IOToggle</project>
        <configuration>GPIO_IOToggle</configuration>
      </member>
      <member>
        <project>IWDG_Reset</project>
        <configuration>IWDG_Reset</configuration>
      </member>
      <member>
        <project>OPAMP_PGA</project>
        <configuration>OPAMP_PGA</configuration>
      </member>
      <member>
        <project>PWR_CurrentConsumption</project>
        <configuration>PWR_CurrentConsumption</configuration>
      </member>
      <member>
        <project>PWR_STANDBY</project>
        <configuration>PWR_STANDBY</configuration>
      </member>
      <member>
        <project>PWR_STOP</project>
        <configuration>PWR_STOP</configuration>
      </member>
      <member>
        <project>Demo</project>
        <configuration>STM32F3_Discovery_Demo</configuration>
      </member>
      <member>
        <project>RCC_Example</project>
        <configuration>RCC_Example</configuration>
      </member>
      <member>
        <project>RTC_Calendar</project>
        <configuration>RTC_Calendar</configuration>
      </member>
      <member>
        <project>RTC_Tamper</project>
        <configuration>RTC_Tamper</configuration>
      </member>
      <member>
        <project>SysTick_Example</project>
        <configuration>SysTick_Example</configuration>
      </member>
      <member>
        <project>TIM_Asymetric</project>
        <configuration>TIM_Asymetric</configuration>
      </member>
      <member>
        <project>TIM_Combined</project>
        <configuration>TIM_Combined</configuration>
      </member>
      <member>
        <project>TIM_ComplementarySignals</project>
        <configuration>TIM_ComplementarySignals</configuration>
      </member>
      <member>
        <project>TIM_PWM_Input</project>
        <configuration>TIM_PWM_Input</configuration>
      </member>
      <member>
        <project>TIM_Rettrigreable_OPM</project>
        <configuration>TIM_Rettrigreable_OPM</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>TIM_TimeBase</configuration>
      </member>
      <member>
        <project>USB_Example</project>
        <configuration>USB_Example</configuration>
      </member>
      <member>
        <project>WWDG_Example</project>
        <configuration>WWDG_Example</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


