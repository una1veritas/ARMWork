# Keil uVision project usb_hid.uvproj, settings and files
target LPC11Uxx FLASH (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: usb_hid
  c include: .\inc;..\..\Common\inc;..\comps\mw_common;..\comps\mw_usbd
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Library
    ../../Common/src/: clkconfig.c core_cm0.c gpio.c system_LPC11Uxx.c uart.c startup_LPC11Uxx.s
  group Source
    ./src/: main.c hid_lpc11uxx_usbdesc.c lpc11uxx_usbd_hid.c
  group Documentation
    ./: readme.txt
