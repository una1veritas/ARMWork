# Keil uVision project usb_msc_hid_dfu.uvproj, settings and files
target LPC11Uxx FLASH (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: usb_msc_hid_dfu
  c flags: Optim=1
  c include: ..\..\Common\inc;..\comps\hw_usbd_ip3511;..\comps\mw_usbd;.\inc;..\comps\mw_common
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Library
    ../../Common/src/: clkconfig.c core_cm0.c system_LPC11Uxx.c startup_LPC11Uxx.s uart.c
  group Source
    ./src/: main.c sbl_iap.c DiskImg.c comp_lpc11uxx_usbdesc.c dfu_lpc11uxx_usbdesc.c hid_lpc11uxx_usbdesc.c lpc11uxx_usbd_dfu.c lpc11uxx_usbd_hid.c lpc11uxx_usbd_msc_mem.c
  group Documentation
    ./: readme.txt
