# Keil uVision project LPC11U24LCD.uvproj, settings and files
target lpclcd (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11U24LCD +hex
  AfterMake: objcopy -I ihex -O binary LPC11U24LCD.hex LPC11U24LCD.bin
  c flags: Optim=4
  c include: ..\..\CMSISv2p00_LPC11Uxx\inc;..\inc;..\src
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group startup
    ./: startup_LPC11Uxx.s
  group main
    ../src/: main.c system_LPC11Uxx.c
  group library
    ../src/: systick.c i2c.c i2clcd.c uart.c xprintf.c gpio.c
  group cmsis2.0
    ../../CMSISv2p00_LPC11Uxx/src/: core_cm0.c
